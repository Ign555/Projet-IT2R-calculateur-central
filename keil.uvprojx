# Keil uVision project keil.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.3.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: keil
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: main.c dfplayermini.c Lib_UART.c pwm_moteur.c dfplayermini.h Lib_UART.h osObjects.h pwm_moteur.h reception_bluetooth.c reception_bluetooth.h
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS:Keil RTX 4.82.0, Board Support:Buttons 1.0.0, Board Support:Graphic LCD 1.0.0, CMSIS Driver:SPI:SSP 2.10.0, CMSIS Driver:USART 2.13.0, Device:GPDMA 1.4.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
